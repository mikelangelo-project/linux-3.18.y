## drivers/stats/Kconfig
```kconfig
config STATS_MODULE
	tristate "A Simple statistics something."
        default m
	---help---
	don't use me
```
